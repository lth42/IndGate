# Keil uVision project Project.uvprojx, settings and files
target GD32F407VG (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F407VG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: GD32F407VG_Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F407
  c include: ..\User;..\Hardware;..\Libraries\CMSIS\Include;..\Libraries\GD32F4xx_std_periph\Include;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group User
    ../User/: main.c gd32f4xx_it.c systick.c
  group Hardware
    ../Hardware/: led.c led_test.c
  group CMSIS
    ../Libraries/CMSIS/Source/: system_gd32f4xx.c
  group Peripherals
    ../Libraries/GD32F4xx_std_periph/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group FreeRTOS
    ../Middlewares/FreeRTOS/src/: tasks.c list.c queue.c timers.c event_groups.c stream_buffer.c
    ../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
  group Startup
    ../Libraries/CMSIS/Startup/: startup_gd32f407_427.s
software components: CMSIS:CORE 5.5.0
